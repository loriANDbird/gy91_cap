# Keil uVision project GY31SampV1.00.uvprojx, settings and files
target GY31SampV1.0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GY31sampV10 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin --output  ..\..\Output\GY31sampV10.bin ..\..\Output\GY31sampV10.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\SysTick;..\..\STM32_USB-FS-Device_Driver\inc;..\..\Mass_Storage\inc;..\..\User\ff9;..\..\JlinkRTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Systick.c USART.c AdcCS1237.c
    ../../Libraries/FWlib/src/: stm32f10x_flash.c
  group RTT
    ../../JlinkRTT/: SEGGER_RTT.c SEGGER_RTT_Printf.c
software components: CMSIS:CORE 4.1.0
